# IAR project App_lpc55s69evk_iar940.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S69_core0 NXP LPC55S69_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: SMX_DEBUG=1
  ICCARM.PreInclude: ..\..\..\CFG\iararm.h
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\XBASE\; ..\..\..\XSMX\; ..\..\..\EHEAP\; ..\..\..\SSMX\; ..\..\..\SSMX\ARMM\; ..\..\..\BSP\; ..\..\..\BSP\ARM\; ..\..\..\BSP\ARM\LPC55Sxx\; ..\..\..\BSP\ARM\LPC55Sxx\NXP\CMSIS\; ..\..\..\BSP\ARM\LPC55Sxx\NXP\; ..\..\..\BSP\ARM\LPC55Sxx\NXP\drivers\; ..\..\..\BSP\ARM\LPC55Sxx\LPC55S69EVK\; ..\..\..\XFS\; ..\..\..\XFFS2\; ..\..\..\XNS\include; ..\..\..\XUSBH\; ..\..\..\XUSBD\; ..\..\..\XUSBD\Core\; ..\..\..\XUSBD\DCD\; ..\..\..\XUSBD\Function\; ..\..\..\XWIFI\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.ADefines: SMX_DEBUG=1
  AARM.AUserIncludes: ..\..\; ..\..\..\CFG\; ..\..\..\XBASE\; ..\..\..\XSMX\; ..\..\..\BSP\; ..\..\..\BSP\ARM\; ..\..\..\BSP\ARM\LPC55Sxx\; ..\..\..\BSP\ARM\LPC55Sxx\NXP\CMSIS\; ..\..\..\BSP\ARM\LPC55Sxx\NXP\; ..\..\..\BSP\ARM\LPC55Sxx\NXP\drivers\; ..\..\..\BSP\ARM\LPC55Sxx\LPC55S69EVK\; ..\..\..\XFS\; ..\..\..\XFFS2\; ..\..\..\XNS\include; ..\..\..\XUSBH\; ..\..\..\XUSBD\; ..\..\..\XWIFI\
  AARM.PreInclude: ..\..\..\CFG\iararm.h
  OBJCOPY.OOCOutputFile: App_lpc55s69evk_iar840.srec
  ILINK.IlinkOutputFile: AppDbg.out
  ILINK.IlinkIcfFile: lpc55s69evk_app_mpu.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ROM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: App_at91sam3u4e_iar610.srec
  ILINK.IlinkOutputFile: AppRom.out
  group (top)
    ../../: app.c
  group Config
    ../../: acfg.h
  group Demos
    ../../DEMO/: fpudemo.c leddemo.c
  group LPC55S69EVK
    ../../../BSP/ARM/LPC55Sxx/: clock.c hwmain.c irqtable.c startup.c uart.c vectors.c
    ../../../BSP/ARM/: fpudemofunm_iar.s
    ../../../BSP/ARM/LPC55Sxx/LPC55S69EVK/: led.c
  group NXP
    ../../../BSP/ARM/LPC55Sxx/NXP/drivers/: fsl_clock.c fsl_common.c fsl_flexcomm.c fsl_gpio.c fsl_power.c fsl_reset.c fsl_usart.c
  group Protosystem
    ../../../BSP/ARM/: bspm.c
    ../../: main.c sys.c
    ../../../SSMX/ARMM/: mpa8.c mpu.c svc.c
    ../../../XBASE/: smxaware.c
  group XBASE
    ../../../XBASE/: bbase.c bcon.c bmsg.c mwmods.c
    ../../../SSMX/: cpcli.c cpsvr.c fportlc.c fportls.c tportlc.c tportls.c
    ../../../EHEAP/: eheap.c
  group XSMX
    ../../../XSMX/: xarmm.c xarmm_iar.s xblk.c xeg.c xem.c xeq.c xevb.c xglob.c xgo.c xheap.c xht.c xlsr.c xmsg.c xmtx.c xpblk.c xpipe.c xpmsg.c xprof.c xsched.c xsem.c xsmx.c xsys.c xtask.c xtime.c xtmr.c
