<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\App_lpc55s69evk_iar940.ewp</path>
  </project>
  <batchBuild/>
</workspace>



