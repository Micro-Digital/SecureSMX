# IAR project App_stm32746g_iar940.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F756NG ST STM32F756NG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: SMX_DEBUG=1
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.PreInclude: ..\..\..\CFG\iararm.h
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\XBASE\; ..\..\..\XSMX\; ..\..\..\EHEAP\; ..\..\..\SSMX\; ..\..\..\SSMX\ARMM\; ..\..\..\BSP\; ..\..\..\BSP\ARM\; ..\..\..\BSP\ARM\STM32\; ..\..\..\BSP\ARM\STM32\STM32F7xx\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STM32746G-EVAL\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\STM32756G_EVAL\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\ampire480272\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\exc7200\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\stmpe811\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\ts3510\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\mfxstm32l152\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\CMSIS\Device\ST\STM32F7xx\Include\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\CMSIS\Include\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\STM32F7xx_HAL_Driver\Inc\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Projects\STM32756G_EVAL\Templates\Inc\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Utilities\STM32_EVAL\Common\Fonts\; ..\..\..\XMW\; ..\..\..\XMW\FatFs\; ..\..\..\XMW\FatFs\drivers\; ..\..\..\XMW\FatFs\portal\; ..\..\..\XPORT\CM\; ..\..\..\XFS\; ..\..\..\XNS\include\; ..\..\..\XUSBD\; ..\..\..\XUSBD\Core\; ..\..\..\XUSBD\DCD\; ..\..\..\XUSBD\Function\; ..\..\..\XUSBH\; ..\..\..\XUSBH\Audio\; ..\..\..\XUSBH\CDC\; ..\..\..\XUSBH\HCD\; ..\..\..\XUSBH\HID\; ..\..\..\XUSBH\Hub\; ..\..\..\XUSBH\MassStor\; ..\..\..\XUSBH\Printer\; ..\..\..\XUSBH\USBD\; ..\..\..\XWIFI\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.ADefines: SMX_DEBUG=1
  AARM.AUserIncludes: ..\..\; ..\..\..\CFG\; ..\..\..\XBASE\; ..\..\..\XSMX\; ..\..\..\BSP\; ..\..\..\BSP\ARM\; ..\..\..\BSP\ARM\STM32\; ..\..\..\BSP\ARM\STM32\STM32F7xx\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STM32746G-EVAL\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\STM32756G_EVAL\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\ampire480272\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\exc7200\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\stmpe811\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\ts3510\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\mfxstm32l152\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\CMSIS\Device\ST\STM32F7xx\Include\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\CMSIS\Include\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\STM32F7xx_HAL_Driver\Inc\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Projects\STM32756G_EVAL\Templates\Inc\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Utilities\STM32_EVAL\Common\Fonts\; ..\..\..\XFS\; ..\..\..\XNS\include\; ..\..\..\XUSBD\; ..\..\..\XUSBH\
  AARM.PreInclude: ..\..\..\CFG\iararm.h
  OBJCOPY.OOCOutputFile: App_stm32746g_iar940.srec
  ILINK.IlinkOutputFile: AppDbg.out
  ILINK.IlinkIcfFile: stm32746g_app_mpu.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\XBASE\; ..\..\..\XSMX\; ..\..\..\EHEAP\; ..\..\..\SSMX\; ..\..\..\SSMX\ARMM\; ..\..\..\BSP\; ..\..\..\BSP\ARM\; ..\..\..\BSP\ARM\STM32\; ..\..\..\BSP\ARM\STM32\STM32F7xx\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STM32746G-EVAL\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\STM32756G_EVAL\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\ampire480272\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\exc7200\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\stmpe811\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\ts3510\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\mfxstm32l152\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\CMSIS\Device\ST\STM32F7xx\Include\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\CMSIS\Include\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\STM32F7xx_HAL_Driver\Inc\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Projects\STM32756G_EVAL\Templates\Inc\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Utilities\STM32_EVAL\Common\Fonts\; ..\..\..\XMW\; ..\..\..\XMW\FatFs\; ..\..\..\XMW\FatFs\drivers\; ..\..\..\XMW\FatFs\portal\; ..\..\..\XPORT\CM; ..\..\..\XFS\; ..\..\..\XNS\include\; ..\..\..\XUSBD\; ..\..\..\XUSBD\Core\; ..\..\..\XUSBD\DCD\; ..\..\..\XUSBD\Function\; ..\..\..\XUSBH\; ..\..\..\XUSBH\Audio\; ..\..\..\XUSBH\CDC\; ..\..\..\XUSBH\HCD\; ..\..\..\XUSBH\HID\; ..\..\..\XUSBH\Hub\; ..\..\..\XUSBH\MassStor\; ..\..\..\XUSBH\Printer\; ..\..\..\XUSBH\USBD\; ..\..\..\XWIFI\
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: AppRel.out
configuration ROM (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: AppRom.out
  group Config
    ../../: acfg.h
  group Demos
    ../../DEMO/: ffpdemo.c fpudemo.c leddemo.c
    ../../../BSP/ARM/STM32/STM32F7xx/STM32746G-EVAL/: lcddemo.c
  group Protosystem
    ../../: app.c main.c sys.c
    ../../../BSP/ARM/: bspm.c
    ../../../SSMX/ARMM/: mpa7.c mpu.c svc.c
    ../../../XBASE/: mwmods.c smxaware.c smxmods.c
  group STM32746
    ../../../BSP/ARM/STM32/STM32F7xx/STM32746G-EVAL/: clock.c lcd.c led.c pin.c
    ../../../BSP/ARM/: fpudemofunm_iar.s
    ../../../BSP/ARM/STM32/STM32F7xx/: hwmain.c irqtable.c reset.c startup.c vectors.c
    ../../../BSP/ARM/STM32/: uartif7.c
  group STM32746/STMicro
    ../../../BSP/ARM/STM32/STM32F7xx/STMicroHAL/Drivers/BSP/Components/exc7200/: exc7200.c
    ../../../BSP/ARM/STM32/STM32F7xx/STMicroHAL/Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../BSP/ARM/STM32/STM32F7xx/STMicroHAL/Drivers/BSP/STM32756G_EVAL/: stm32756g_eval.c stm32756g_eval_io.c stm32756g_eval_lcd.c stm32756g_eval_sd.c stm32756g_eval_sdram.c stm32756g_eval_sram.c
    ../../../BSP/ARM/STM32/STM32F7xx/STMicroHAL/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_sram.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c
    ../../../BSP/ARM/STM32/STM32F7xx/STMicroHAL/Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../BSP/ARM/STM32/STM32F7xx/STMicroHAL/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
    ../../../BSP/ARM/STM32/STM32F7xx/STMicroHAL/Drivers/BSP/Components/ts3510/: ts3510.c
  group XBASE
    ../../../XBASE/: bbase.c bcc.c bcon.c bmsg.c
    ../../../SSMX/: cpcli.c cpsvr.c fportlc.c fportls.c tportlc.c tportls.c
    ../../../EHEAP/: eheap.c
  group XMW/FatFs
    ../../../XMW/FatFs/option/: ccsbcs.c syscall.c
    ../../../XPORT/CM/: cm2port.c
    ../../../XMW/FatFs/: diskio.c ff.c ff_gen_drv.c
    ../../../XMW/FatFs/portal/: ffpcli.c ffpsvr.c
    ../../../XMW/FatFs/drivers/: sd_diskio_dma_rtos_bspv1.c
  group XSMX
    ../../../XSMX/: xarmm.c xarmm_iar.s xblk.c xeg.c xem.c xeq.c xevb.c xglob.c xgo.c xheap.c xht.c xlsr.c xmsg.c xmtx.c xpblk.c xpipe.c xpmsg.c xprof.c xsched.c xsem.c xsmx.c xsys.c xtask.c xtime.c xtmr.c
