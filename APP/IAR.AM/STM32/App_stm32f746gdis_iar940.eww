<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\App_stm32f746gdis_iar940.ewp</path>
  </project>
  <batchBuild/>
</workspace>


