# IAR project App_stm32f746gdis_iar940.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: SMX_DEBUG=1
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.PreInclude: ..\..\..\CFG\iararm.h
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\XBASE\; ..\..\..\XSMX\; ..\..\..\EHEAP\; ..\..\..\SSMX\; ..\..\..\SSMX\ARMM\; ..\..\..\BSP\; ..\..\..\BSP\ARM\; ..\..\..\BSP\ARM\STM32\; ..\..\..\BSP\ARM\STM32\STM32F7xx\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STM32746G-DISC\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\STM32746G-Discovery\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\Common\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\CMSIS\Device\ST\STM32F7xx\Include\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\CMSIS\Include\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\STM32F7xx_HAL_Driver\Inc\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Projects\STM32746G-Discovery\Templates\Inc\; ..\..\..\XMW\; ..\..\..\XMW\FatFs\; ..\..\..\XMW\FatFs\drivers\; ..\..\..\XMW\FatFs\portal\; ..\..\..\XPORT\CM\; ..\..\..\XFS\; ..\..\..\XNS\include\; ..\..\..\XUSBD\; ..\..\..\XUSBD\Core\; ..\..\..\XUSBD\DCD\; ..\..\..\XUSBD\Function\; ..\..\..\XUSBH\; ..\..\..\XUSBH\Audio\; ..\..\..\XUSBH\CDC\; ..\..\..\XUSBH\HCD\; ..\..\..\XUSBH\HID\; ..\..\..\XUSBH\Hub\; ..\..\..\XUSBH\MassStor\; ..\..\..\XUSBH\Printer\; ..\..\..\XUSBH\USBD\; ..\..\..\XWIFI\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.ADefines: SMX_DEBUG=1
  AARM.AUserIncludes: ..\..\; ..\..\..\CFG\; ..\..\..\XBASE\; ..\..\..\XSMX\; ..\..\..\BSP\; ..\..\..\BSP\ARM\; ..\..\..\BSP\ARM\STM32\; ..\..\..\BSP\ARM\STM32\STM32F7xx\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STM32746G-DISC\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\STM32746G-Discovery\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\Common\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\CMSIS\Device\ST\STM32F7xx\Include\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\CMSIS\Include\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\STM32F7xx_HAL_Driver\Inc\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Projects\STM32746G-Discovery\Templates\Inc\; ..\..\..\XMW\; ..\..\..\XMW\FatFs\; ..\..\..\XMW\FatFs\drivers\; ..\..\..\XMW\FatFs\portal\; ..\..\..\XFS\; ..\..\..\XNS\include\; ..\..\..\XUSBD\; ..\..\..\XUSBH\
  AARM.PreInclude: ..\..\..\CFG\iararm.h
  OBJCOPY.OOCOutputFile: App_stm32f746gdis_iar940.srec
  ILINK.IlinkOutputFile: AppDbg.out
  ILINK.IlinkIcfFile: stm32746g_app_mpu.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\XBASE\; ..\..\..\XSMX\; ..\..\..\EHEAP\; ..\..\..\SSMX\; ..\..\..\SSMX\ARMM\; ..\..\..\BSP\; ..\..\..\BSP\ARM\; ..\..\..\BSP\ARM\STM32\; ..\..\..\BSP\ARM\STM32\STM32F7xx\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STM32746G-DISC\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\STM32746G-Discovery\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\Common\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\CMSIS\Device\ST\STM32F7xx\Include\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\CMSIS\Include\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\STM32F7xx_HAL_Driver\Inc\; ..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Projects\STM32746G-Discovery\Templates\Inc\; ..\..\..\XMW\; ..\..\..\XMW\FatFs\; ..\..\..\XMW\FatFs\drivers\; ..\..\..\XMW\FatFs\portal\; ..\..\..\XPORT\CM; ..\..\..\XFS\; ..\..\..\XNS\include\; ..\..\..\XUSBD\; ..\..\..\XUSBD\Core\; ..\..\..\XUSBD\DCD\; ..\..\..\XUSBD\Function\; ..\..\..\XUSBH\; ..\..\..\XUSBH\Audio\; ..\..\..\XUSBH\CDC\; ..\..\..\XUSBH\HCD\; ..\..\..\XUSBH\HID\; ..\..\..\XUSBH\Hub\; ..\..\..\XUSBH\MassStor\; ..\..\..\XUSBH\Printer\; ..\..\..\XUSBH\USBD\; ..\..\..\XWIFI\
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: AppRel.out
configuration ROM (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: App_stm32746g_iar940.srec
  ILINK.IlinkOutputFile: AppRom.out
  group Config
    ../../: acfg.h
  group Demos
    ../../DEMO/: ffpdemo.c fpudemo.c leddemo.c
    ../../../BSP/ARM/STM32/STM32F7xx/STM32746G-DISC/: lcddemo.c
  group Protosystem
    ../../: app.c main.c sys.c
    ../../../BSP/ARM/: bspm.c
    ../../../SSMX/ARMM/: mpa7.c mpu.c svc.c
    ../../../XBASE/: mwmods.c smxaware.c smxmods.c
  group STM32746G-DISC
    ../../../BSP/ARM/STM32/STM32F7xx/STM32746G-DISC/: clock.c lcd.c led.c pin.c
    ../../../BSP/ARM/: fpudemofunm_iar.s
    ../../../BSP/ARM/STM32/STM32F7xx/: hwmain.c irqtable.c reset.c startup.c vectors.c
    ../../../BSP/ARM/STM32/: uartif7.c
  group STM32746G-DISC/STMicro/BSP
    ../../../BSP/ARM/STM32/STM32F7xx/STMicroHAL/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c
  group STM32746G-DISC/STMicro/CMSIS
    ../../../BSP/ARM/STM32/STM32F7xx/STMicroHAL/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group STM32746G-DISC/STMicro/HAL_Driver
    ../../../BSP/ARM/STM32/STM32F7xx/STMicroHAL/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_gpio.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c
  group XBASE
    ../../../XBASE/: bbase.c bcc.c bcon.c bmsg.c
    ../../../SSMX/: cpcli.c cpsvr.c fportlc.c fportls.c tportlc.c tportls.c
    ../../../EHEAP/: eheap.c
  group XMW/FatFs
    ../../../XMW/FatFs/option/: ccsbcs.c syscall.c
    ../../../XPORT/CM/: cm2port.c
    ../../../XMW/FatFs/: diskio.c ff.c ff_gen_drv.c
    ../../../XMW/FatFs/portal/: ffpcli.c ffpsvr.c
    ../../../XMW/FatFs/drivers/: sd_diskio_dma_rtos_bspv1.c
  group XSMX
    ../../../XSMX/: xarmm.c xarmm_iar.s xblk.c xeg.c xem.c xeq.c xevb.c xglob.c xgo.c xheap.c xht.c xlsr.c xmsg.c xmtx.c xpblk.c xpipe.c xpmsg.c xprof.c xsched.c xsem.c xsmx.c xsys.c xtask.c xtime.c xtmr.c
