<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\tx_stm32f746gdis_iar940.ewp</path>
    </project>
    <batchBuild />
</workspace>
