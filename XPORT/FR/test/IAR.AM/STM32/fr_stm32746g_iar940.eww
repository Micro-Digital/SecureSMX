<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\fr_stm32746g_iar940.ewp</path>
    </project>
    <batchBuild />
</workspace>
