# IAR project fr_stm32f746gdis_iar940.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: SMX_DEBUG=1
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.PreInclude: ..\..\..\..\..\CFG\iararm.h
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\..\APP\; ..\..\..\..\..\XBASE\; ..\..\..\..\..\XSMX\; ..\..\..\..\..\XPORT\FR\; ..\..\..\..\..\XPORT\FR\include\; ..\..\Demo\Common\Minimal; ..\..\Demo\Common\include; ..\..\Demo\STM32F7; ..\..\Demo\STM32F7\Full_Demo; ..\..\Source; ..\..\Source\include; ..\..\..\..\..\EHEAP\; ..\..\..\..\..\SSMX\; ..\..\..\..\..\SSMX\ARMM\; ..\..\..\..\..\BSP\; ..\..\..\..\..\BSP\ARM\; ..\..\..\..\..\BSP\ARM\STM32\; ..\..\..\..\..\BSP\ARM\STM32\STM32F7xx\; ..\..\..\..\..\BSP\ARM\STM32\STM32F7xx\STM32746G-DISC\; ..\..\..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\STM32746G-Discovery\; ..\..\..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\Common\; ..\..\..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\CMSIS\Device\ST\STM32F7xx\Include\; ..\..\..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\CMSIS\Include\; ..\..\..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\STM32F7xx_HAL_Driver\Inc\; ..\..\..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Projects\STM32746G-Discovery\Templates\Inc\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.ADefines: SMX_DEBUG=1
  AARM.AUserIncludes: ..\..\; ..\..\..\..\..\CFG\; ..\..\..\..\..\XBASE\; ..\..\..\..\..\XSMX\; ..\..\..\..\..\BSP\; ..\..\..\..\..\BSP\ARM\; ..\..\..\..\..\BSP\ARM\STM32\; ..\..\..\..\..\BSP\ARM\STM32\STM32F7xx\; ..\..\..\..\..\BSP\ARM\STM32\STM32F7xx\STM32746G-DISC\; ..\..\..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\STM32746G-Discovery\; ..\..\..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\BSP\Components\Common\; ..\..\..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\CMSIS\Device\ST\STM32F7xx\Include\; ..\..\..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\CMSIS\Include\; ..\..\..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Drivers\STM32F7xx_HAL_Driver\Inc\; ..\..\..\..\..\BSP\ARM\STM32\STM32F7xx\STMicroHAL\Projects\STM32746G-Discovery\Templates\Inc\
  AARM.PreInclude: ..\..\..\..\..\CFG\iararm.h
  OBJCOPY.OOCOutputFile: fr_stm32f746gdis_iar940.srec
  ILINK.IlinkOutputFile: TfrDbg.out
  ILINK.IlinkIcfFile: stm32746g_fr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 0
  ILINK.IlinkOutputFile: TfrRel.out
configuration ROM (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: TfrRom.out
  group FRdemo
    ../../Demo/STM32F7/Full_Demo/: IntQueueTimer.c main_full.c RegTest_IAR.s
  group FRdemo/Common
    ../../Demo/Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c EventGroupsDemo.c flash.c flop.c GenQTest.c integer.c IntQueue.c IntSemTest.c PollQ.c QPeek.c QueueOverwrite.c QueueSet.c recmutex.c semtest.c TaskNotify.c TimerDemo.c
  group FRPort
    ../../../: croutine.c event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
  group Source
    ../../: app.c tfrp.c
  group Source/Protosystem
    ../../../../../BSP/ARM/: bspm.c
    ../../../../../BSP/ARM/STM32/STM32F7xx/STM32746G-DISC/: clock.c pin.c
    ../../../../../BSP/ARM/STM32/STM32F7xx/: irqtable.c startup.c vectors.c
    ../../../../../APP/: main.c sys.c
    ../../../../../SSMX/ARMM/: mpu.c svc.c
    ../../../../../XBASE/: mwmods.c smxaware.c
  group Source/STM32746
    ../../../../../BSP/ARM/STM32/STM32F7xx/: hwmain.c
    ../../../../../BSP/ARM/STM32/STM32F7xx/STM32746G-DISC/: lcd.c led.c
    ../../../../../BSP/ARM/STM32/: uartif7.c
  group Source/STM32746/STMicro/BSP
    ../../../../../BSP/ARM/STM32/STM32F7xx/STMicroHAL/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sdram.c
  group Source/STM32746/STMicro/CMSIS
    ../../../../../BSP/ARM/STM32/STM32F7xx/STMicroHAL/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Source/STM32746/STMicro/HAL_Driver
    ../../../../../BSP/ARM/STM32/STM32F7xx/STMicroHAL/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_gpio.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c
  group Source/XBASE
    ../../../../../XBASE/: bbase.c bcon.c bmsg.c
    ../../../../../SSMX/: cpcli.c cpsvr.c fportlc.c fportls.c tportlc.c tportls.c
    ../../../../../EHEAP/: eheap.c
  group Source/XSMX
    ../../../../../XSMX/: xarmm.c xarmm_iar.s xblk.c xeg.c xem.c xeq.c xevb.c xglob.c xgo.c xheap.c xht.c xlsr.c xmsg.c xmtx.c xpblk.c xpipe.c xpmsg.c xprof.c xsched.c xsem.c xsmx.c xsys.c xtask.c xtime.c xtmr.c
